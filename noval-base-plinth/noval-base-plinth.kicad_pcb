File: noval-base-plinth/noval-base-plinth.kicad_pcb (KiCad board)
At the start: 2 copper layers, 100 x 100 mm, 15 parts

Commit message: Updating to KiCad 9.0
Other:
- net class Default removed
